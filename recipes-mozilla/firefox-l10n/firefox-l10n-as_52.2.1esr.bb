# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f678b01599696eb65207cfe966a4b36d"
SRC_URI[sha256sum] = "100b1a86e3ad0096eacb83f96664c55ed7689290fed7469ebc0790cfd4b362ed"
