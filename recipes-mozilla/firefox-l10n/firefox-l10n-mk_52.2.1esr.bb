# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a456641df7cece6dbed8556c74f0469"
SRC_URI[sha256sum] = "136314fc16c701cf38680a0737fa028a03f297ae47ee78481e95c74f3a65546a"
