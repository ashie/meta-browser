# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f4a6a63bfe3741af895c04b9945117f"
SRC_URI[sha256sum] = "8e5795ace208aa88a6652b5e8dde0e391dfd22a586b3dbff9a982eaf60a29a9f"
