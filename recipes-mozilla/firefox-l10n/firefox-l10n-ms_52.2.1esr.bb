# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e41b2596b29e024824d2fc2bf38f480"
SRC_URI[sha256sum] = "7c7474347c7765847e9a2919d4a12e46fe6b5dac85b6580779d65fa7564124fe"
