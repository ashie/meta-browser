# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1bde8e65b6cf6f0dbdac125ab32f1009"
SRC_URI[sha256sum] = "57523eca0d44a3f8cdd319b4789886ac1ff59f629d6b247937642dc2b8b70a47"
