# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7086893034992db90fa910f4dc929ebd"
SRC_URI[sha256sum] = "2c86ab76fa9c7a4dc2edd522eee73cce6ebe42be1799d8c87885e20ac1c8e1d0"
