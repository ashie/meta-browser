# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1020b19532239106d71cb7c86bb725a"
SRC_URI[sha256sum] = "aad2ed1c36a3b4345a75f92c7ef04157aff053fe689c664681556c53b5dc6da1"
