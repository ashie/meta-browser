# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c97ca536decfb8c34c7105e397b5b11"
SRC_URI[sha256sum] = "be2db5f5fff287c8c83b68ccdbad09a844eef5016eab5fb69def997fb77f27ef"
