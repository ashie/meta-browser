# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db3f06d1eee8655c1f0c84a308623249"
SRC_URI[sha256sum] = "4b0845538487c9160c92b3cff9745a511430101708d8fdec8e668d4219308f48"
