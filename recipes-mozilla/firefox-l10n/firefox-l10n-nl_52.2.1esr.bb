# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db441cb4ddf87c3a2e6f8bed0d558f7b"
SRC_URI[sha256sum] = "0110aa8cd97c1aca6f654b3af23a177ff99673daaa1838325739850fa4b6493d"
