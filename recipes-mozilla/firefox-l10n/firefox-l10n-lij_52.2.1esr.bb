# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f6d25e7a1c2cccf4d1293163232a5d7"
SRC_URI[sha256sum] = "e59c03c7752b322905822cb0dd056b566baaeabfbecbe5cdd5d4e748ac70d12d"
