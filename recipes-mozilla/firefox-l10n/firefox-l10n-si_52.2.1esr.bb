# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89fde4352ba7f5abf8db72f388ab421a"
SRC_URI[sha256sum] = "a98945fd6c1920f518565a20a591f0320659471dff003868388ad5f2c6913c3f"
