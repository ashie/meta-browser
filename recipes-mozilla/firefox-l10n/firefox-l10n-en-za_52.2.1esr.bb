# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ea6af62251f358010544a3963b16d53"
SRC_URI[sha256sum] = "8476c9f6f0b322199dd6773945806c4f5e193587683028ebc50f8da8a7df29aa"
