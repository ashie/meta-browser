# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45d6d02610e4be2fa0e1b9ab87de5f12"
SRC_URI[sha256sum] = "a91f8948f8dd389241949b1e608dd585ac759b7ea4fc7cd75038dc1cb490ed67"
