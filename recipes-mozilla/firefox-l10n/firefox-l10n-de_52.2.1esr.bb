# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92ff783daee8fd8e561c5d4568f4263e"
SRC_URI[sha256sum] = "42a54ff904f22f376c0d0c12bd5fa8676a06ba1de22023c61fe57c48cab9e12f"
