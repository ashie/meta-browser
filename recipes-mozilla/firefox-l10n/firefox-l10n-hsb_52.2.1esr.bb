# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5df39da1bb6e576b69938090ed47eedc"
SRC_URI[sha256sum] = "22b0472f98006f6ebe00a5823c0e10a19d09895499ae56ce8cbd10f1b57193de"
