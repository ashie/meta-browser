# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26c1286e0da3295f2a16ed2db4275c43"
SRC_URI[sha256sum] = "46336f145148267cb911205e675b213ad707a386651b4363a17b229516e08adb"
