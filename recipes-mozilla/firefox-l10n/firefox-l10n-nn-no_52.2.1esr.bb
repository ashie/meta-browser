# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46bfbaaba9e542603455a21fb06123f0"
SRC_URI[sha256sum] = "16413c5b055ef5737f6614336d000a0f1aa9b4bc7df103e9e473422435df68a2"
