# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f92537ce8f2201ff482eb6a1b43dcb3"
SRC_URI[sha256sum] = "ea3a01c466b2b91344821592bde95e50b97dfa31a741303b95525c9256aec7c0"
