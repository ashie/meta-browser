# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b78f12d8190a70f958d71d03d35af0ef"
SRC_URI[sha256sum] = "95e750788d1b5fed076d170d177db8aaf3b3a8be6b0a96ccc57cb9dd65ac362b"
