# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c05d94e59c290db84c11d9285c540d0"
SRC_URI[sha256sum] = "c2f29eb7e0a5056d873db01862883d8615bd594598fcd60c8138a612f3aa4bcc"
