# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3aa5a952738896f9497f5e12acb28904"
SRC_URI[sha256sum] = "5891baad8f5229e0afe676b3293b43cc61f419204ba247402ef866a34f816a40"
