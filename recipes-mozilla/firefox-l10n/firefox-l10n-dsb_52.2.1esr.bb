# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be5ddf1418aebbe09cf81dd4451d6119"
SRC_URI[sha256sum] = "47d951eab1cf5cf7f08652ab5f92e189c8b1b2b53cf93b9c9cf501a7e8586f0e"
