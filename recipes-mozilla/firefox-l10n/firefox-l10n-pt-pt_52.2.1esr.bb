# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "922649fce669351ffd086ebb36380816"
SRC_URI[sha256sum] = "13db70d3d845ac9948ce10c2fe71197fbdd4306ffd2e86c65eaabf66e9142ce9"
