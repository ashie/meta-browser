# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72ac4b348ef2de11ee818578b7a54555"
SRC_URI[sha256sum] = "e55f5f2590103bb2aaa87c436c6d23927be2e7da8a463666ff2fdeb503103109"
