# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebd24a4b3f3cc7572f34910c802de1c9"
SRC_URI[sha256sum] = "ffb864450510a979e72b028d6f1335628d1b6bb16bb9875f046d51cbca0e0159"
