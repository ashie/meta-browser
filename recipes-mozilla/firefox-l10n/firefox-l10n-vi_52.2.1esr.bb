# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c61c5f4a5823ddb8be51ae2005feed91"
SRC_URI[sha256sum] = "349fbadda7f160a91ae312c0f34a1f542d8f364c9fdcd090ff336e39b01e2c65"
