# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79e25e6938dff2fe5ef21cda8a7c24a2"
SRC_URI[sha256sum] = "828a7889e5e1d5c5b24048b8fb8ac4c0dcbde0887eff6151e6ef3ca652b4d3d8"
