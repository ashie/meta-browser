# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4de2cfe61c67511bba58b5fb0a96d515"
SRC_URI[sha256sum] = "539185551af3eba416b87c3f8d6d48b2e4b5ce0ed7005dfa4e0a0490b9767df8"
