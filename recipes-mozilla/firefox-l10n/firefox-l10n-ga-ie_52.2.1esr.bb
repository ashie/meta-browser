# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "528acdf934ac396dcbcba3a6b3fe9cf6"
SRC_URI[sha256sum] = "6b02bccd2e4a1bb1e92e813d3caaa148e609c02373d884a628cb6aebeea38b85"
