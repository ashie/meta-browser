# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a617cbfc1223e3997246a9e63ce96591"
SRC_URI[sha256sum] = "78c9133ffe356f8126714df406ac267773a6fed3ddc786d9172d1f2bf313ad17"
