# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4d1882ec55131becf6814e6a6c5f843"
SRC_URI[sha256sum] = "a61350ceaa5962826ed1a14f16b96833a30db4c5656ea5362056250d0adc5105"
