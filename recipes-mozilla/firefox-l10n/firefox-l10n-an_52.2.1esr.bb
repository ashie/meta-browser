# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ad8ccae30e534afc0470c78961066e6"
SRC_URI[sha256sum] = "63e536ea0a98eed0ef2bfe34c06ea5ec1389292df6c65117f75af31655be2854"
