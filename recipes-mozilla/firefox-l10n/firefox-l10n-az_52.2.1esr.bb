# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c976c17f0f61bc892536e0fd3d90574"
SRC_URI[sha256sum] = "d5b002192f07d1d36ff6a2bb9fd564b771ee2e2068edb6206bee1e8de046bba5"
