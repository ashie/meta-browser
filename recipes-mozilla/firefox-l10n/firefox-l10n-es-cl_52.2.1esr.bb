# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3cd99c44a2ae486ed5884d4895f0284"
SRC_URI[sha256sum] = "7239dcce45cea11374ab275109d0086f7b5bc5b475b659e0ecff03fa07f4aec7"
