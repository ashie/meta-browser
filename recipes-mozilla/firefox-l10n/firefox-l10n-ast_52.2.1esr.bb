# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9b2ad48fef52eacb51b0fe19ededd08"
SRC_URI[sha256sum] = "e697473b44a01d358af1e50f3dd02ed381f965648068e5adf3bba8acf7dd9de4"
