# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79a72c90b681534fd3f51f183e95b498"
SRC_URI[sha256sum] = "c1cd2afa828ea6d35d518357112b843575689417e942c4e5c4b9e606c1f6b3c7"
