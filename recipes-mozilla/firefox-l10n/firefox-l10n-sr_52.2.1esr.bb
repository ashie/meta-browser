# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab0ea4de3e8421194e16a76d8da9ae12"
SRC_URI[sha256sum] = "b79cea0b4b91be15e6a9725bd80e441a09f4cc8c6d56b4440bda86bf5fb9b633"
