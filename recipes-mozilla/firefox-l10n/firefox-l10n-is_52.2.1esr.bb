# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "665e673be1c3075281bbe8e6a91904e8"
SRC_URI[sha256sum] = "df59d4fcee80e62f5236b22314e6cdc7737a6fa87216df2ce465903e3cebf451"
