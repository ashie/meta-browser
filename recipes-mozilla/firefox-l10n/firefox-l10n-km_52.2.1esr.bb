# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42cafce809e5f9545f3cae0a57f863ef"
SRC_URI[sha256sum] = "a7d2cb4c5a0373654676dcd10a342c7b94ba8a884c4975823a5cf9ebc67f3b31"
