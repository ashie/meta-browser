# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6b9b3e245f2760d613a0a92de0990da"
SRC_URI[sha256sum] = "ffae33b22a590c10f4443a4d03afe5d5f3c6935de0ecc3bface16d480a54eeca"
