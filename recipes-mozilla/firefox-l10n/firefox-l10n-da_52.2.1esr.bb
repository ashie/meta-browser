# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92544ed188dfd795344932e559e891e0"
SRC_URI[sha256sum] = "654dc48a03f40688bf19956580fea4999afb3761b14e3b9624558d0f99cc899d"
