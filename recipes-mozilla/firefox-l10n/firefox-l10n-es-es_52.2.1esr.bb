# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "870de38359c79b0bc7fc51ceecdac675"
SRC_URI[sha256sum] = "45114c93ac215a19393c44b33f31e135014914e0b323e7ac87a0563977a1390e"
