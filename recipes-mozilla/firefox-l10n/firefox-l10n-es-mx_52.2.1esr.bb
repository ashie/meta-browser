# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e2c01d6e326d511303f267f676ce6d2"
SRC_URI[sha256sum] = "f57a26513c9a5fe9ee3e6ae484f6b58f374826b7f9c5fe761f3a8de541601f17"
