# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffe186b4988da5df8462408d8e1d0c25"
SRC_URI[sha256sum] = "cfb8b2cddc8438b9dcddb1c3701d38d1c66b6db83b58eea0abdf82826d9cf5dd"
