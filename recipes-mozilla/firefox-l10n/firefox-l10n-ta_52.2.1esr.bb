# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbf1f57287a831e01636ded2beaf7f5f"
SRC_URI[sha256sum] = "379c748f8be7dbecd02db4274c9368e8af1590ef5b7732d37457d59e375aee71"
