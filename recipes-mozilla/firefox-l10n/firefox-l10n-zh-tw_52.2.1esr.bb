# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d147c44836d880aeb39ec86dca03670b"
SRC_URI[sha256sum] = "4d70207576f6ffb9ee07ab2619abeb0b3c0605b0aae581bcf514843821094fcf"
