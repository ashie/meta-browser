# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c9b77063d0496752c93b1b9ddc274f5"
SRC_URI[sha256sum] = "035898b48fa7e5050a6c6dc73aa867866c7f32c00f73bbf7e49c035f623f44f6"
