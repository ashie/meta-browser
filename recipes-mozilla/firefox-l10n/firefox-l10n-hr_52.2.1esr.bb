# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fd8c5dd621411a95fed41436df7276d"
SRC_URI[sha256sum] = "79f603fc20abe2043704f3b6d84b4f171b7267adcf9d737e538b9d44be575747"
