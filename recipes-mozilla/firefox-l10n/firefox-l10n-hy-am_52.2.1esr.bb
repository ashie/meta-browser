# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "271831a53debac35c36c16f96251321c"
SRC_URI[sha256sum] = "faa79506c758344d9f6b9fc027b4fdaafe430d13d2471dfc7ec020db1a618838"
