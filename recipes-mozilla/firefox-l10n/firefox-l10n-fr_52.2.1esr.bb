# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e1368a2c2bee6a1952021d8305a0b5d"
SRC_URI[sha256sum] = "ca6d1042661f5ed47a1a8e937cad3da1b7844def118e17edbc9da48a26ddee4a"
