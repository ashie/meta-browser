# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca04e2f9df36e73064f5f3f972c226c0"
SRC_URI[sha256sum] = "9092d82ec96bc36c4a18b742da903a8574242ff7602ba9eb4340d35f2cb2d338"
