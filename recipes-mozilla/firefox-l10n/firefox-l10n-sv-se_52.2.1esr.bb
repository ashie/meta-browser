# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c906fe8e7fc7c2718981bc3e08e48d5d"
SRC_URI[sha256sum] = "6efe321bc62c17d8d249d0afca8094b395349b3a8d7c9dc296b2c77b38acadf3"
