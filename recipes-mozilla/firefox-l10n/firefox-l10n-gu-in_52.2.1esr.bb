# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95aaf0bcd7169917031b759e5d699381"
SRC_URI[sha256sum] = "1c92d76b9b828304cb67b66baa043d4c5e814d41f114ab28e67922fe95f99570"
