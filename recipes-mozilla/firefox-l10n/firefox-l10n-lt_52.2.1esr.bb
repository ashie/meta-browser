# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c8f5a2ebd1b2d08c0a556f8ab394814"
SRC_URI[sha256sum] = "4b1e0e6ea00db63bba50fb6d899e900e51d760861cc122a4a7c0917b11e89984"
