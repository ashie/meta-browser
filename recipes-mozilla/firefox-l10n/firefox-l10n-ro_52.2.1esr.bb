# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c349ea5c594a2bee7d4275f65d1ae6b3"
SRC_URI[sha256sum] = "536e52c56ae374ac067c75f72bc19a3817e8a9a2f44d9b06db080b82ef161a83"
