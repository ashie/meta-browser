# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "115a87c98829485166afb8b053d397bc"
SRC_URI[sha256sum] = "f0e2bca02c4f9735382dd45da8a6fd6185f316d0e71f99a14df8a1c76db151e0"
