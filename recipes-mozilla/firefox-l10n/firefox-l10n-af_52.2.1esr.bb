# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1ecca35d6763ed9d74d07ddb2f02575"
SRC_URI[sha256sum] = "9f2ed40d747af31fbb217f60cafba3b10b5a3c07ec3c56fa06d01896ea47b53d"
