# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "707c38c79d00d568b3921a94fe19cdcc"
SRC_URI[sha256sum] = "a63103754d85735556f52c38ab7a34310a6f8e32f7dd4e443bf04e040696cafa"
