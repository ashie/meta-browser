# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55b576fb6bb7c5e6895f3ae1962d2f4d"
SRC_URI[sha256sum] = "f7a4887513654d0b452130eaeea09d27dcdf4b72dee6b84ea2d4a7a7474aa8b7"
