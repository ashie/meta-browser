# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98174fd2957a782abfe55fcb212ab476"
SRC_URI[sha256sum] = "0f19ace8e85e5efd278c155d4b6e684da2ddc7ac31a257e3aca56b46c6d3593a"
