# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0bdc50a76c491067ebaee089bd5408b9"
SRC_URI[sha256sum] = "5c4416896bf26573e47e53f8ed98f2db5d154cb1f5620b3b8ee1f675273d29cd"
