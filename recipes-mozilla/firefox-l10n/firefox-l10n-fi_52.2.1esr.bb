# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91b5633152dd2d277043544b8a033d40"
SRC_URI[sha256sum] = "01ba30743517d6055646f55fbd9ea78ff40b9a328665b2cff2c2554f6db5bbb7"
