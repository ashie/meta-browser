# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19e52ca752cc4dd7f7a45414f2b25f56"
SRC_URI[sha256sum] = "6f322acba8e1ac1c80897d552b0414dea7e8fa8509b838162278d1d09c7906b8"
