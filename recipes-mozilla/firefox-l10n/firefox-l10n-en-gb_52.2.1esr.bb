# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49f68150a615ee36cac2954c96813687"
SRC_URI[sha256sum] = "10b0b869ebf9eefbe2593200baeee6546331af120e1bc318de0340780aff16b8"
