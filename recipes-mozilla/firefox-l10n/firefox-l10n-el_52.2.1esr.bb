# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba698dc6dd34009b98bfc7660b193220"
SRC_URI[sha256sum] = "123f9c56895356e900eb6185249f2def18b241074313688776373652dc68bffb"
