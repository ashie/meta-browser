# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a4bb26762dcb0449ca22437b995695b"
SRC_URI[sha256sum] = "95450026065b4d73ff52ba04d7d600e7ef74f4ddc2ae45ba26d0a8236395c0fe"
