# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adb3afd8c8979c1bec33bf2d0d9bce09"
SRC_URI[sha256sum] = "6ff5ee0948c09ab7376b7bdab807832c5b1579c230ececef99fc2614c7a1d997"
