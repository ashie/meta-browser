# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "440faee4ef241de2ce5447f758a8539e"
SRC_URI[sha256sum] = "8d4f5f9f9df5ff0c541fa27b3bfd6104ccc5cecb9350c99735d8e27a14818c18"
