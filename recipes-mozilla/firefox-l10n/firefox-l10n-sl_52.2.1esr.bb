# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d70e38a70ea9436786ef4519562fbae2"
SRC_URI[sha256sum] = "7e37e5019bbe78306eebb70609db38605480812eb87b262b589337a8d597790f"
