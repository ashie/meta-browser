# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef7d8212052d85fb9699b057d09605e0"
SRC_URI[sha256sum] = "e0bcd57cd4f650518ece9a7c0db05c965e09b57ca031915819c3176eb4bae082"
