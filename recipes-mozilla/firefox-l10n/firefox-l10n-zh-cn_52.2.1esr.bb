# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "307f27e5bff2d4465ac9f41416661554"
SRC_URI[sha256sum] = "3839268e26cea482c15b6923233da752991c91a297b2a38ffe58d14ac2089485"
