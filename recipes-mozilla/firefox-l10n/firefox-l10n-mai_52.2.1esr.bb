# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "186b4c5fd41236d705e8369c2f4a91c0"
SRC_URI[sha256sum] = "2c56f03cf8d843c8ecd09a89c61f9ce59cf3daa4d6f7251da4f435b0bd2414ac"
