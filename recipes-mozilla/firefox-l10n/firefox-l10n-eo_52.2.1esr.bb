# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99cb3e0b29b801c500388715402d42a5"
SRC_URI[sha256sum] = "608edc5f6082d2f54b55d1dfd6f200894ee165e69a7564a363538a5351e7c1ff"
