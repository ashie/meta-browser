# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "908b646eeebb205766876e26a450aa8a"
SRC_URI[sha256sum] = "843b533b14fda446a2e630fd1f63ff680121f1bfb6e6a694ef2eddfe78bd78d6"
