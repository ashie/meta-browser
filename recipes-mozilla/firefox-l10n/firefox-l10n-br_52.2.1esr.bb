# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d5cc0f8890138946fb4d1498425ac48"
SRC_URI[sha256sum] = "3db61e3b47bfd247b5213297acd8af880ee27cc12968d1402476d4335d3456ed"
