# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ed65615f400e21f2f4e143be783995d"
SRC_URI[sha256sum] = "ecf0f7c60cc3075b1d6101ad69b76810b350b001935a926fdcbf0a258df5f301"
