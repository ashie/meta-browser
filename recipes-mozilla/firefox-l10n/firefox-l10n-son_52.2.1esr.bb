# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6df43c034f3c68cd6d424ea6bd3bafdf"
SRC_URI[sha256sum] = "c2d99424d7b5d4a2c2759cb383619a5411d904d2e81626eb3de2ac0c4998a4ee"
