# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0538e502dd717a087b845316df0a77b7"
SRC_URI[sha256sum] = "170960f9e0acd2c92151d66ad52c139bf6adf1c40cbb7ee6b1551b3a2bcc068d"
