# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4c7ad1ba92eb1a1521b80274a72cb6e"
SRC_URI[sha256sum] = "445eaad51d60c4ecbe8c0f2cd3518ee3345e1d49ee4a1a1acd880a752ad2a26b"
