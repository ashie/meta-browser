# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f606d1bac2413322b2b742f72fdcc081"
SRC_URI[sha256sum] = "25964f0093ef5f00ba174ebf87c3f9aced7809e75edc090b2033f563da48ec9c"
