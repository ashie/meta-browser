# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50b30ad49ca301045dc42fc7aefb0384"
SRC_URI[sha256sum] = "865be40fdad5b65ef9831621780b38d7397cbb2dd7679a6e885e19310cc30853"
