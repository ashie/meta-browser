# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee022d9105842407f6ad9501e0859ffe"
SRC_URI[sha256sum] = "603640ac685a4021ea0907ce85f75bcb217bf92d295ba86edc26511f4de3e467"
