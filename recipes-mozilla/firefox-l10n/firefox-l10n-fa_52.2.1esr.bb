# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05bfe60bbd67ff74da0ccb101198a352"
SRC_URI[sha256sum] = "3e08f0061a5fbac8d24f30f1428a68bc7c24b9f20d769fddfc152c512e5a2efb"
