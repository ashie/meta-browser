# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27e12061d1b269a9dda39436f29dd7e5"
SRC_URI[sha256sum] = "b1c0a845ae525d0c9a40b20c93b1f16982d19938893737a376ca00588f0acbda"
