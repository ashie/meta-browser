# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27c2a829e969f832e06afa70d121aa60"
SRC_URI[sha256sum] = "01d1ad49e58021d2e8121d9f46564322f7664e7547972b301740318be63b4631"
