# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d25ce5bb1436e1102b52a35e12240f27"
SRC_URI[sha256sum] = "26afac7bb581907b1462df6cfb154f75d66c4d1ae7d2952794a589ced5e52518"
