# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a63e0729d570c2c643384212a88bc98c"
SRC_URI[sha256sum] = "3b59b2c7546e655828b6f3a42698e321a386fcb39c7d72b669cad45d17ca05e5"
