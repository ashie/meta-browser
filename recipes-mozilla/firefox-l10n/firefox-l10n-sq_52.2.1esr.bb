# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98f4db7694a35e6079c7b2303ca507f0"
SRC_URI[sha256sum] = "b99c6349486638db297a3d6ab929fcab6d377903e3a12d4a7cddee05e531e81d"
